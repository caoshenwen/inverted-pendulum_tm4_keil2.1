# Keil uVision project freertos-TM4C123GXL.uvprojx, settings and files
target Flight Control (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos-TM4C123GXL +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: .\USER;.\CONTROL;.\HARDWARE;.\PARAMETER;.\ALGORITHM;.\LIBRARY;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\DataScope_DP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./USER/: main.c startup_rvmdk.S usr_tasks.c inverted pendulum.c
    ./FreeRTOS/: my_include.c
  group CONTROL
    ./CONTROL/: PID.c
  group HARDWARE
    ./HARDWARE/: ADC.c delay.c GPIO_Init.c key.c PWM_Model.c QEI_Model.c Timer_Init.c UART_Init.c drv_led.c usartHmi.c
    ./LIBRARY/utils/: uartstdio.c
  group LIBRARY
    ./LIBRARY/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group OS-CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group OS-PORT
    ./FreeRTOS/portable/MemMang/: heap_2.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DataScope_DP
    ./DataScope_DP/: DataScope_DP.C show.c
